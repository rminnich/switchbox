## arch/x86/vmthread/Kconfig
```kconfig
config VMTHREAD
	bool "vmthread support"
	select TTY
	select VIRTUALIZATION
	select VIRTIO
	select VIRTIO_CONSOLE
	help
	  vmthreads
```
